## boards/u-blox/ubx_evk_iris_w1/Kconfig
```kconfig
# Copyright 2025 NXP
# SPDX-License-Identifier: Apache-2.0


config BOARD_UBX_EVK_IRIS_W1
	select BOARD_EARLY_INIT_HOOK
```
